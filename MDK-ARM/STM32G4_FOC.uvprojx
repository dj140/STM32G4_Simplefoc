# Keil uVision project STM32G4_FOC.uvprojx, settings and files
target STM32G4_FOC (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32G4_FOC +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,ARDUINO=111,STM32G431xx
  c misc: --gnu
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;..\Lib;..\Lib\avr;..\Drivers;..\Arduino-FOC\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.cpp
  group user
    ../Core/Src/: stm32g4xx_it.c usart.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_ll_pwr.c stm32g4xx_ll_usart.c stm32g4xx_ll_rcc.c stm32g4xx_ll_dma.c stm32g4xx_ll_adc.c stm32g4xx_ll_comp.c stm32g4xx_ll_cordic.c stm32g4xx_ll_crc.c stm32g4xx_ll_crs.c stm32g4xx_ll_dac.c stm32g4xx_ll_hrtim.c stm32g4xx_ll_i2c.c stm32g4xx_ll_lptim.c stm32g4xx_ll_lpuart.c stm32g4xx_ll_opamp.c stm32g4xx_ll_rng.c stm32g4xx_ll_rtc.c stm32g4xx_ll_spi.c stm32g4xx_ll_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Lib
    ../Lib/: Arduino.c dtostrf.c itoa.c HardwareSerial.cpp Print.cpp Stream.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp SPI.cpp
  group core
    ../Drivers/: delay.c exti.c gpio.c timer.c pwm.c
  group Arduino_FOC
    ../Arduino-FOC/src/: BLDCMotor.cpp
    ../Arduino-FOC/src/common/: foc_utils.cpp lowpass_filter.cpp pid.cpp time_utils.cpp
    ../Arduino-FOC/src/common/base_classes/: CurrentSense.cpp FOCMotor.cpp Sensor.cpp
    ../Arduino-FOC/src/communication/: Commander.cpp SimpleFOCDebug.cpp
    ../Arduino-FOC/src/current_sense/: GenericCurrentSense.cpp
    ../Arduino-FOC/src/drivers/: BLDCDriver3PWM.cpp BLDCDriver6PWM.cpp
    ../Arduino-FOC/src/sensors/: Encoder.cpp GenericSensor.cpp HallSensor.cpp MagneticSensorAnalog.cpp MagneticSensorI2C.cpp MagneticSensorPWM.cpp MagneticSensorSPI.cpp
software components: CMSIS:CORE 5.6.0
